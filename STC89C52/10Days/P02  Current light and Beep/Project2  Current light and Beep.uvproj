# Keil uVision project Project2  Current light and Beep.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project2  Current light and Beep +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: Project2  Current light and Beep.c
