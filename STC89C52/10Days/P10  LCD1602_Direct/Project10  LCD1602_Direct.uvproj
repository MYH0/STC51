# Keil uVision project Project10  LCD1602_Direct.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: P10  LCD1602_Direct +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c
