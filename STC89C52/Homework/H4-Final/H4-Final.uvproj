# Keil uVision project H4-Final.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: H4-Final +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c
